<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Alcohol.ewp</path>
  </project>
  <batchBuild/>
</workspace>


